# Keil uVision project BudgetNAS.uvproj, settings and files
target Target 1 (MCS-51)
  device: DP8051 Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000)
  output: BudgetNAS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: wizmemcpy.c delay.c main.c serial.c socket.c sockutil.c TCPIPCore.c STARTUP.A51 lcd.c ataoe.c
